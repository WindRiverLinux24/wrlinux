LINUX-YOCTO_INC_WRLINUX = ""
LINUX-YOCTO_INC_WRLINUX:osv-wrlinux = "${LAYER_PATH_wrlinux}/recipes-kernel/linux/linux-yocto-wrlinux.inc"
require ${LINUX-YOCTO_INC_WRLINUX}
